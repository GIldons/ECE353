# Keil uVision project S15_HW3.uvprojx, settings and files
target S15-HW3 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.0.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(80000000) ELITTLE
  output: ece353_base_project
  c flags: Optim=1
  c misc: --debug
  c include: C:\Keil_v5\ARM\Pack\ARM\CMSIS\3.20.4\CMSIS\Include;..\include
  asm misc: --debug
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group src
    ./: main.c boardUtil.c interrupts.c
  group lib
    ../lib/: ece353_uart.lib
  group Drivers
    ../drivers/: gpioPort.c adc.c timer0.c
  group New Group
    ../include/: adc.h circular_buffer.h sysctrl.h systick.h timer0.h uart.h
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0
